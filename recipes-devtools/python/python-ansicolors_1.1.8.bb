require python-ansicolors.inc
inherit setuptools
