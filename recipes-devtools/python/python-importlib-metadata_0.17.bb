require python-importlib-metadata.inc
inherit setuptools
