require python-zipp.inc
inherit setuptools3
