require python3-labgrid.inc

SRC_URI += "git://github.com/labgrid-project/labgrid.git;protocol=https;branch=${SRCBRANCH}"

SRCBRANCH = "stable-23.0"
SRCREV = "7a63be1682f174ff29584bf178c3fa077c582dcb"
