inherit setuptools3
require python-txaio.inc

SRC_URI[md5sum] = "c998be8d5837218c809266c0fce94687"
SRC_URI[sha256sum] = "17938f2bca4a9cabce61346758e482ca4e600160cbc28e861493eac74a19539d"
