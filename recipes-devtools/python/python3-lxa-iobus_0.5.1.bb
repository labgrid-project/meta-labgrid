require python3-lxa-iobus.inc

SRCBRANCH = "master"
SRCREV = "1d90a81eef5a61fd0d2bfdcd72a7a1e98cbf1290"
