require python3-usbsdmux.inc

SRCBRANCH = "master"
SRCREV = "051f3816aea89623aaa24b6720e92442f03e2f76"
