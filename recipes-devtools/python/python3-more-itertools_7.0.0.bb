require python-more-itertools.inc
inherit setuptools3
