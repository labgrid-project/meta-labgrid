require python3-labgrid.inc

SRC_URI += "git://github.com/labgrid-project/labgrid.git;protocol=https;branch=${SRCBRANCH}"

SRCBRANCH = "stable-25.0"
SRCREV = "4b2f81389386454a0eb84e361e776ea818ffb038"
