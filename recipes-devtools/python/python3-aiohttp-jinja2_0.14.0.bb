inherit setuptools3
require python-aiohttp-jinja2.inc

SRC_URI[md5sum] = "bba85ec200649ecdbb98259de622a21f"
SRC_URI[sha256sum] = "44fedf0102ac632f0746f1bf72b5a71cf6326c9c2d13993c66789a838675924c"
