inherit setuptools3
require python-txaio.inc
