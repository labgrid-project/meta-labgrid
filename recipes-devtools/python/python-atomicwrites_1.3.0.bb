require python-atomicwrites.inc
inherit setuptools
