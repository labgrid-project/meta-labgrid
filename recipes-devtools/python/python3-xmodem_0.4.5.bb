inherit setuptools3
require python-xmodem.inc

SRC_URI[md5sum] = "af8d14e7c0219a62b9f5d413176bd00a"
SRC_URI[sha256sum] = "8b7ca0f45cdf0f5e7212a60931c98b333da5ef2fc6702a5d10c51b9fc52ce91c"
