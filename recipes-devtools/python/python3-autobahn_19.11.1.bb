inherit setuptools3
require python-autobahn.inc

SRC_URI[md5sum] = "472d965c75dba0f8cb5f3b9f9001ed1b"
SRC_URI[sha256sum] = "201b9879b49c6e259d4126dbafe9e3c73807de0c242d50065fbebc62c6ccb181"
