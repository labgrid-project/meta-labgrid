require python3-lxa-iobus.inc

SRCBRANCH = "master"
SRCREV = "8f7c26c1b376d1664c7fb22472c7ff3ea2a0f010"
