inherit setuptools3
require python-graphviz.inc

SRC_URI[md5sum] = "ca0a501d256cbbbf52a2e0ccef7a2bcf"
SRC_URI[sha256sum] = "865afa6ab9775cf29db03abd8e571a164042c726c35a1b3c1e2b8c4c645e2993"
