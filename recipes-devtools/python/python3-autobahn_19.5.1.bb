inherit setuptools3
require python-autobahn.inc
