require python3-labgrid.inc

SRC_URI += "git://github.com/labgrid-project/labgrid.git;protocol=https;branch=${SRCBRANCH}"

SRCBRANCH = "stable-25.0"
SRCREV = "6d8febb7263f772bb5d0b4aed85f268f7968412e"
