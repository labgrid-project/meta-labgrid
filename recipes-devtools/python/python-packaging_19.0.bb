require python-packaging.inc
inherit setuptools
